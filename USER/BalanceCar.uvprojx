# Keil uVision project BalanceCar.uvprojx, settings and files
target BalanceCar (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BalanceCar +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CORE;..\FWLib\inc;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\timer;..\HARDWARE\motor;..\HARDWARE\LED;..\HARDWARE\I2C;..\HARDWARE\systick;..\HARDWARE\car;..\HARDWARE\MPU6050;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\HARDWARE\Remote
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c delay.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/I2C/: I2C.c
    ../HARDWARE/systick/: systick.c
    ../HARDWARE/car/: car.c
    ../HARDWARE/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/Remote/: Remote.c
